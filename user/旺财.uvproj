# Keil uVision project 旺财.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 旺财 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\program
  group Source Group 1
    ./: STARTUP.A51
    ../program/: main.c Delay.C Key.C LCD1602.c i2c.c eeprom.c Coded_Lock.c
